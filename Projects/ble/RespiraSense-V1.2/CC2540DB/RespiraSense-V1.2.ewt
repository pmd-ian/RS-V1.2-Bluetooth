<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>PMD</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-STAT</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <cstatargs>
          <useExtraArgs>0</useExtraArgs>
          <extraArgs></extraArgs>
        </cstatargs>
        <cstatsettings/>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <file>
      <name>$PROJ_DIR$\..\Source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\OSAL_init.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_rpc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>CC2540EB</name>
        <group>
          <name>Config</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_board_cfg.h</name>
          </file>
        </group>
        <group>
          <name>Drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_key.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_startup.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_uart.c</name>
          </file>
        </group>
        <group>
          <name>Includes</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_ccm.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_dma.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_mcu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\Components\hal\target\CC2540EB\hal_types.h</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\CC2540DB\bin\CC2540_BLE_peri.lib</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Libraries\Common\bin\CC254x_BLE_HCI_TL_None.lib</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\bcomdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_bufmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\osal_cbtimer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_ClockBLE.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\COMPONENTS\osal\mcu\cc2540\osal_snv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
  </group>
  <group>
    <name>PMD</name>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_hw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_hw.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_Service1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_Service1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_Service2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\PMD_Service2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\pmd_snv_ids.h</name>
    </file>
  </group>
  <group>
    <name>PROFILES</name>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\gapbondmgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gapgattserver.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\host\gatt_uuid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Components\ble\include\gatt_uuid.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Include\gattservapp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\GATT\gattservapp_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\peripheral.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\Profiles\Roles\CC254x\peripheral.h</name>
    </file>
  </group>
  <group>
    <name>TOOLS</name>
    <file>
      <name>$PROJ_DIR$\..\..\config\buildComponents.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\buildConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\lnk51ew_cc2530b_banked_rom_data.xcl</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\lnk_banked_rom_data.xcl</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\cc2540\OnBoard.h</name>
    </file>
  </group>
</project>


